/* Record the GPU command streams for "linear XRGB framebuffer -> tiled scanout" so the
 * kernel can replay them without libxe. Records twice with two arenas at different
 * physical addresses; words that move with the arena are relocations.
 * Output: a C header for the kernel module. */
#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <string.h>
#include "../libxe/xe.h"
#include "../libxe/xe_linux.h"

#define SRC_MARK 0x5A5A0000u
#define DST_MARK 0x6B6B0000u
#define ARENA    (4u << 20)
#define RING_BYTES 0x100000u   /* libxe secondary ring: first allocation, not replayed */

static unsigned char shader_3d_ps[] = {
	0x10, 0x2a, 0x11, 0x00, 0x00, 0x00, 0x00, 0xdc, 0x00, 0x00, 0x00, 0x48,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0xb4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x8c, 0x00, 0x00, 0x00, 0x1c, 0x00, 0x00, 0x00, 0x7f,
	0xff, 0xff, 0x03, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1c,
	0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x44,
	0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x54,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x03, 0x00, 0x00,
	0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x00,
	0x6c, 0x69, 0x67, 0x68, 0x74, 0x44, 0x69, 0x72, 0x65, 0x63, 0x74, 0x69,
	0x6f, 0x6e, 0x00, 0xab, 0x00, 0x01, 0x00, 0x03, 0x00, 0x01, 0x00, 0x04,
	0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x00, 0xab, 0xab,
	0x00, 0x04, 0x00, 0x0c, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x70, 0x73, 0x5f, 0x33, 0x5f, 0x30, 0x00, 0x32,
	0x2e, 0x30, 0x2e, 0x37, 0x36, 0x38, 0x30, 0x2e, 0x30, 0x00, 0xab, 0xab,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x48, 0x10, 0x00, 0x01, 0x00,
	0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1c, 0x42,
	0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x70, 0x30,
	0x00, 0x00, 0xf1, 0x50, 0x00, 0x01, 0x10, 0x02, 0x00, 0x00, 0x12, 0x00,
	0xc4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x22, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x10, 0x08, 0x10, 0x21, 0x1f, 0x1f, 0xf6, 0x88,
	0x00, 0x00, 0x40, 0x00, 0xc8, 0x01, 0x00, 0x00, 0x00, 0xbe, 0xbe, 0x00,
	0xb0, 0x00, 0x00, 0x00, 0x14, 0x87, 0x80, 0x00, 0x00, 0x6c, 0xc0, 0x1b,
	0xe1, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00
};

static unsigned char shader_3d_vs[] = {
	0x10, 0x2a, 0x11, 0x01, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x00, 0xb4,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0xb8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x1c, 0x00, 0x00, 0x00, 0x83,
	0xff, 0xfe, 0x03, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1c,
	0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x44,
	0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x04,
	0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6c, 0x00, 0x00, 0x00, 0x00,
	0x6d, 0x6f, 0x64, 0x65, 0x6c, 0x56, 0x69, 0x65, 0x77, 0x00, 0xab, 0xab,
	0x00, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x6d, 0x6f, 0x64, 0x65, 0x6c, 0x57, 0x6f, 0x72,
	0x6c, 0x64, 0x00, 0xab, 0x00, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x03,
	0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x76, 0x73, 0x5f, 0x33,
	0x5f, 0x30, 0x00, 0x32, 0x2e, 0x30, 0x2e, 0x37, 0x36, 0x38, 0x30, 0x2e,
	0x30, 0x00, 0xab, 0xab, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xb4,
	0x00, 0x11, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x1c, 0x42, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
	0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x90, 0x00, 0x10, 0x00, 0x03,
	0x00, 0x00, 0x30, 0x04, 0x00, 0x20, 0x50, 0x05, 0x00, 0x00, 0x70, 0x30,
	0x00, 0x03, 0xf1, 0x50, 0x00, 0x00, 0x00, 0x0b, 0x00, 0x00, 0x00, 0x0c,
	0x00, 0x00, 0x10, 0x0d, 0x00, 0x00, 0x10, 0x0a, 0x70, 0x15, 0x30, 0x03,
	0x00, 0x00, 0x12, 0x00, 0xc2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x06,
	0x00, 0x00, 0x12, 0x00, 0xc4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0a,
	0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xf8, 0x20, 0x00,
	0x00, 0x00, 0x06, 0x88, 0x00, 0x00, 0x00, 0x00, 0x05, 0xf8, 0x00, 0x00,
	0x00, 0x00, 0x04, 0x47, 0x00, 0x00, 0x00, 0x00, 0x05, 0xf8, 0x10, 0x00,
	0x00, 0x00, 0x06, 0x88, 0x00, 0x00, 0x00, 0x00, 0xc8, 0x01, 0x80, 0x3e,
	0x00, 0xa7, 0xa7, 0x00, 0xaf, 0x02, 0x00, 0x00, 0xc8, 0x02, 0x80, 0x3e,
	0x00, 0xa7, 0xa7, 0x00, 0xaf, 0x02, 0x01, 0x00, 0xc8, 0x04, 0x80, 0x3e,
	0x00, 0xa7, 0xa7, 0x00, 0xaf, 0x02, 0x02, 0x00, 0xc8, 0x08, 0x80, 0x3e,
	0x00, 0xa7, 0xa7, 0x00, 0xaf, 0x02, 0x03, 0x00, 0xc8, 0x0f, 0x80, 0x01,
	0x00, 0x00, 0x00, 0x00, 0xe2, 0x01, 0x01, 0x00, 0xc8, 0x01, 0x80, 0x00,
	0x00, 0xc3, 0xbe, 0x00, 0xb0, 0x00, 0x04, 0x00, 0xc8, 0x02, 0x80, 0x00,
	0x00, 0xc3, 0xbe, 0x00, 0xb0, 0x00, 0x05, 0x00, 0xc8, 0x04, 0x80, 0x00,
	0x00, 0xc3, 0xbe, 0x00, 0xb0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};



struct rec { uint32_t *init, *frame[3]; size_t ninit, nframe[3]; uint8_t *arena; uint32_t base; size_t used; };

static void record(struct rec *r, int W, int H)
{
	static struct XenosDevice xe_s; struct XenosDevice *xe = &xe_s;
	if (xe_linux_record_begin(ARENA)) exit(1);
	Xe_Init(xe);
	static const struct XenosVBFFormat vbf = { 5, {
		{XE_USAGE_POSITION, 0, XE_TYPE_FLOAT3}, {XE_USAGE_NORMAL, 0, XE_TYPE_FLOAT3},
		{XE_USAGE_TANGENT, 0, XE_TYPE_FLOAT3}, {XE_USAGE_COLOR, 0, XE_TYPE_UBYTE4},
		{XE_USAGE_TEXCOORD, 0, XE_TYPE_FLOAT2} } };
	struct XenosShader *sps = Xe_LoadShaderFromMemory(xe, shader_3d_ps); Xe_InstantiateShader(xe, sps, 0);
	struct XenosShader *svs = Xe_LoadShaderFromMemory(xe, shader_3d_vs); Xe_InstantiateShader(xe, svs, 0);
	Xe_ShaderApplyVFetchPatches(xe, svs, 0, &vbf);
	float u0 = 0.5f / W, v0 = 0.5f / H, u1 = 1 + 0.5f / W, v1 = 1 + 0.5f / H;
	float quad[] = {
		-1, -1, 0,   0, 0, -1,   1, 0, 0,   0,   u0, v1,
		-1,  1, 0,   0, 0, -1,   1, 0, 0,   0,   u0, v0,
		 1,  1, 0,   0, 0, -1,   1, 0, 0,   0,   u1, v0,
		 1, -1, 0,   0, 0, -1,   1, 0, 0,   0,   u1, v1,
	};
	unsigned short idx[] = { 0, 1, 2, 0, 2, 3 };
	struct XenosVertexBuffer *vb = Xe_CreateVertexBuffer(xe, sizeof(quad));
	memcpy(Xe_VB_Lock(xe, vb, 0, sizeof(quad), XE_LOCK_WRITE), quad, sizeof(quad)); Xe_VB_Unlock(xe, vb);
	struct XenosIndexBuffer *ib = Xe_CreateIndexBuffer(xe, sizeof(idx), XE_FMT_INDEX16);
	memcpy(Xe_IB_Lock(xe, ib, 0, sizeof(idx), XE_LOCK_WRITE), idx, sizeof(idx)); Xe_IB_Unlock(xe, ib);
	Xe_Execute(xe);
	r->init = xe_linux_record_take(&r->ninit);

	/* fake surfaces: addresses are markers patched by the kernel */
	static struct XenosSurface src, dst;
	memset(&src, 0, sizeof src); memset(&dst, 0, sizeof dst);
	src.width = W; src.height = H; src.wpitch = W * 4; src.hpitch = H; src.bypp = 4; src.tiled = 0;
	src.format = XE_FMT_8888 | XE_FMT_ARGB; src.ptr = SRC_MARK; src.base = (void *)1;
	src.use_filtering = 0; src.u_addressing = src.v_addressing = XE_TEXADDR_CLAMP;
	dst.width = W; dst.height = H; dst.wpitch = W * 4; dst.hpitch = (H + 31) & ~31; dst.bypp = 4; dst.tiled = 1;
	dst.format = XE_FMT_8888 | XE_FMT_BGRA; dst.ptr = DST_MARK; dst.base = (void *)1;
	static const float ident[16] = {1,0,0,0, 0,1,0,0, 0,0,1,0, 0,0,0,1};
	float light[4] = {0, 0, -1, 0};
	Xe_SetRenderTarget(xe, &dst);
	for (int f = 0; f < 3; f++) {
		Xe_InvalidateState(xe);
		Xe_SetVertexShaderConstantF(xe, 0, ident, 4);
		Xe_SetVertexShaderConstantF(xe, 4, ident, 4);
		Xe_SetPixelShaderConstantF(xe, 0, light, 1);
		Xe_SetShader(xe, SHADER_TYPE_PIXEL, sps, 0);
		Xe_SetShader(xe, SHADER_TYPE_VERTEX, svs, 0);
		Xe_SetZEnable(xe, 0);
		Xe_SetCullMode(xe, XE_CULL_NONE);
		Xe_SetStreamSource(xe, 0, vb, 0, 12);
		Xe_SetIndices(xe, ib);
		Xe_SetTexture(xe, 0, &src);
		Xe_DrawIndexedPrimitive(xe, XE_PRIMTYPE_TRIANGLELIST, 0, 0, 4, 0, 2);
		Xe_Resolve(xe);
		Xe_Sync(xe);
		r->frame[f] = xe_linux_record_take(&r->nframe[f]);
	}
	xe_linux_record_arena(&r->arena, &r->base, &r->used);
	xe_linux_record_end();
}

/* classify every word: 0 const, 1 reloc (arena offset), 2 src marker, 3 dst marker */
static int classify(const char *what, uint32_t *a, uint32_t *b, size_t n, struct rec *A, struct rec *B,
		    FILE *out, const char *name)
{
	int nrel = 0, nsrc = 0, ndst = 0, bad = 0;
	fprintf(out, "static const u32 %s_words[%zu] = {", name, n);
	for (size_t i = 0; i < n; i++) fprintf(out, "%s0x%08x,", i % 8 ? " " : "\n\t", a[i]);
	fprintf(out, "\n};\n");
	fprintf(out, "/* {word index, kind (1 = arena reloc, 2 = src, 3 = dst), value relative to the base} */\n");
	fprintf(out, "static const struct xegpu_reloc %s_relocs[] = {\n", name);
	for (size_t i = 0; i < n; i++) {
		uint32_t x = a[i], y = b[i];
		if ((x & ~0xfffu) == SRC_MARK) { fprintf(out, "\t{%zu, 2, 0x%x},\n", i, x - SRC_MARK); nsrc++; continue; }
		if ((x & ~0xfffu) == DST_MARK) { fprintf(out, "\t{%zu, 3, 0x%x},\n", i, x - DST_MARK); ndst++; continue; }
		if (x == y) continue;
		if (x - A->base == y - B->base && x - A->base < A->used) {
			fprintf(out, "\t{%zu, 1, 0x%x},\n", i, x - A->base); nrel++; continue;
		}
		fprintf(stderr, "%s: word %zu differs and is not a relocation: %08x vs %08x\n", what, i, x, y);
		bad++;
	}
	fprintf(out, "};\n\n");
	fprintf(stderr, "%s: %zu words, %d relocs, %d src, %d dst, %d unexplained\n", what, n, nrel, nsrc, ndst, bad);
	return bad;
}

int main(int argc, char **argv)
{
	const char *outpath = argc > 1 ? argv[1] : "xegpu_blit_rec.h";
	if (xe_linux_open()) return 1;
	int W = xe_linux_info()->scanout_width, H = xe_linux_info()->scanout_height;
	static struct rec A, B;
	record(&A, W, H);
	record(&B, W, H);
	fprintf(stderr, "arena A %08x used %zu, arena B %08x used %zu\n", A.base, A.used, B.base, B.used);
	if (A.nframe[1] != A.nframe[2] || memcmp(A.frame[1], A.frame[2], A.nframe[1] * 4))
		fprintf(stderr, "warning: frame 2 and 3 differ, not steady state\n");
	if (A.ninit != B.ninit || A.nframe[1] != B.nframe[1]) { fprintf(stderr, "stream lengths differ between runs\n"); return 1; }
	size_t diff = 0;
	for (size_t i = 0; i < A.used; i++) if (A.arena[i] != B.arena[i]) { if (i >= RING_BYTES) fprintf(stderr, "  arena diff at %zx\n", i); diff++; }
	fprintf(stderr, "arena bytes differing between runs: %zu\n", diff);

	FILE *out = fopen(outpath, "w");
	fprintf(out, "/* generated by xerecord: %dx%d linear XRGB -> tiled scanout. Do not edit. */\n", W, H);
	fprintf(out, "#define XEGPU_BLIT_W %d\n#define XEGPU_BLIT_H %d\n", W, H);
	fprintf(out, "struct xegpu_reloc { u32 idx; u32 kind; u32 delta; };\n");
	int bad = classify("init", A.init, B.init, A.ninit, &A, &B, out, "blit_init");
	/* frame 0 carries first-use state; frames 1 and 2 are steady. Replay frame 1 each time. */
	bad += classify("frame", A.frame[1], B.frame[1], A.nframe[1], &A, &B, out, "blit_frame");
	/* the resolve's vertex buffer comes from libxe's pool; after frame 1 it is reused */
	/* the 1MB secondary ring sits at the start of the arena; only what follows is replayed */
	fprintf(out, "#define XEGPU_BLIT_ARENA_SKIP 0x%x\n#define XEGPU_BLIT_ARENA_SIZE %zu\nstatic const u8 blit_arena[%zu] = {", RING_BYTES, A.used - RING_BYTES, A.used - RING_BYTES);
	for (size_t i = RING_BYTES; i < A.used; i++) fprintf(out, "%s0x%02x,", (i - RING_BYTES) % 16 ? "" : "\n\t", A.arena[i]);
	fprintf(out, "\n};\n");
	fclose(out);
	fprintf(stderr, "wrote %s (%d unexplained words)\n", outpath, bad);
	return bad ? 2 : 0;
}
